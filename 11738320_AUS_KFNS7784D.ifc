Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: a1200eca-f303-4c39-ae05-76bf90fe41a5, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:24:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11738320_AUS_KFNS7784D:38778401_AUS_11738320_KFNS7784D, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 546 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 38778401_AUS_11738320_KFNS7784D; sets with these values: 2

# IfcDistributionPort, Port_354172_1
Description: Flow; FlowDirection: SOURCEANDSINK
